DEPENDS += "virtual/libiconv"