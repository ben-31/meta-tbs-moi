PACKAGES:prepend = "ntpdate "
FILES:ntpdate = "${sbindir}/ntpdate"