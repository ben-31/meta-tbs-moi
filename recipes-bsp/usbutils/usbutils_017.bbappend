export LIBS="${@bb.utils.contains('PREFERRED_PROVIDER_virtual/libiconv', 'libiconv', '-liconv', '', d)}"