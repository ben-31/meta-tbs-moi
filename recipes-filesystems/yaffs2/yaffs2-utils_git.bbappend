FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-set-MAX_OBJECTS-to-30000.patch"

